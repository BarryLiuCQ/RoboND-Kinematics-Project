Commit message: compile issue resolved

File: src/kuka_arm/urdf/target.urdf.xacro (robot description, xacro)
@@ -22,5 +22,5 @@
   </link>
   <gazebo reference="target_link_1">
-    <material>Gazebo/Blue</material>
+    <material>Gazebo/RedGlow</material>
     <mu1>1.0</mu1>
     <mu2>1.0</mu2>
